Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: M_Demineralization Unit_MEPcontent_Spirotech_SpiroPure Pro 9.5_INT-EN.ifc
Time: 2025-08-05T18:29:28+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcDistributionPort (2)
Description: Flow; PredefinedType: PIPE
Name | FlowDirection
InPort_2044670_1 | SINK
OutPort_2044670_2 | SOURCE

# IfcValve: M_Demineralization Unit_MEPcontent_Spirotech_SpiroPure Pro_INT-EN:SpiroPure Pro 9.5, M_Demineralization Unit_MEPcontent_Spirotech_SpiroPure Pro_INT-EN:SpiroPure Pro 9.5:2044670
In: F00
Type - Material: Color RGB 200-200-200, Color RGB 200-000-000, Color RGB 168-128-048, Color RGB 055-055-055, Color RGB 150-150-150, Color RGB 229-190-001
Type - Other - Category: Pipe Accessories; b: 618.463 mm; Bottom Offset: 120 mm; d: 110.5 mm; Family Name: M_Demineralization Unit_MEPcontent_Spirotech_SpiroPure Pro_INT-EN; h: 465 mm; Tank Radius: 106 mm
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 221 mm; Height: 532 mm; Use Nominal Diameter: yes; Water Inlet Connection Diameter: 19 mm; Water Outlet Connection Diameter: 19 mm; Width: 624 mm
Type - Electrical - Power Supply LED: Battery - CR2450
Type - Identity Data - Article Description: Build-in demineralization unit - cap. 1350 ltr - Fillcombi; Article Type: SpiroPure Pro 9.5; Base Family Version: 25.09; Content Supplier URL: www.MEPcontent.com; Copyright: ©Trimble Europe BV; Custom: no; Description: Build-in demineralization unit - cap. 1350 ltr - Fillcombi; EMCS Version: 5.0; ETIM Article Class: EC011325; Family Version: 24.10; GLN: 8717811000007; GTIN: 8717811064542; Manufacturer: Spirotech; Manufacturer Art. No.: G76.355; Manufacturer URL: https://www.spirotech.com/8717811064542; MEPcontent Class: FILTER; Model: SpiroPure Pro 9.5; OmniClass Number: 23.75.50.11.14; OmniClass Title: Feedwater Equipment; Product Line: Spirotech; Revit Version: 2023; Type Name: SpiroPure Pro 9.5; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Black: Color RGB 055-055-055; Brass: Color RGB 168-128-048; Grey: Color RGB 150-150-150; White: Color RGB 200-200-200; Yellow: Color RGB 229-190-001
Type - Mechanical - Max Filling Capacity: 1.35 m3; Resin Volume: 0.0095 m3; Weight: 12.2 kg; Working Pressure: 1.5 to 8 bar; Working Temperature: 5 to 40°C
Type - Mechanical - Flow - Max Flow: 0.000166667 m3/s
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_EnvironmentalImpactIndicators - Reference: SpiroPure Pro 9.5; sets with these values: 2
Other - Back Clearance Safe: 0 mm; Bottom Clearance Safe: 0 mm; Family: M_Demineralization Unit_MEPcontent_Spirotech_SpiroPure Pro_INT-EN; Family and Type: M_Demineralization Unit_MEPcontent_Spirotech_SpiroPure Pro_INT-EN: SpiroPure Pro 9.5; Front Clearance Safe: 0 mm; Left Clearance Safe: 0 mm; Right Clearance Safe: 0 mm; Top Clearance Safe: 50 mm; Type: SpiroPure Pro 9.5; Type Id: 2044653
Constraints - Elevation from Level: 0 mm
Dimensions - Area: 0.9231 m2; Maximum Size: 19 mm; Minimum Size: 19 mm; Volume: 0.0175939 m3
Identity Data - Mark: 11
Mechanical - System Classification: Undefined
Mechanical - Flow - Pressure Drop: 0 Pa; Water Inlet Connection Flow: 0 m3/s; Water Outlet Connection Flow: 0 m3/s
Phasing - Phase Created: 3. New Construction
Visibility - Back Clearance: 0 mm; Bottom Clearance: 0 mm; Front Clearance: 0 mm; Left Clearance: 0 mm; Right Clearance: 0 mm; Show Service Area: no; Top Clearance: 50 mm
Insulation - Insulation Thickness: 0 mm
